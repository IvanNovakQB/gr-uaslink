options:
  parameters:
    description: This requires a SITL running.  Source a message and send to a sink on another port
    generate_options: no_gui
    id: test_pymavlink_source_sink
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {state: disabled}
- name: uaslink_pymavlink_sink_p_0
  id: uaslink_pymavlink_sink_p
  parameters:
    baud_rate: '57600'
    connection_string: '''tcp:127.0.0.1:5760'''
  states: {}
- name: uaslink_pymavlink_source_p_1
  id: uaslink_pymavlink_source_p
  parameters:
    baud_rate: '57600'
    connection_string: '''udp:127.0.0.1:14550'''
  states: {}

connections:
- [blocks_message_strobe_0, strobe, uaslink_pymavlink_sink_p_0, MAVLink]
- [uaslink_pymavlink_source_p_1, MAVLink, blocks_message_debug_0, print_pdu]
- [uaslink_pymavlink_source_p_1, MAVLink, uaslink_pymavlink_sink_p_0, MAVLink]

metadata:
  file_format: 1
